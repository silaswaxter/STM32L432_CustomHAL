# Keil uVision project ROM_Sensor.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L432KCUx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: ROM_Sensor
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group User Application
    ./: main.c
  group User Libraries
    ./: HAL_SYSCFG.c HAL_SYSCFG.h ClockControl.c ClockControl.h DMA.c DMA.h EXTI.c EXTI.h FLASH.c FLASH.h GPIO.c GPIO.h USART.c USART.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.3.1
